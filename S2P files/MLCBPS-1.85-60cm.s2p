!China Electronics Technology Instruments Limited Company,3672E,ZFL00052,2.0.3
!Calibration ON : 2P/1,2
!S2P File: Measurements: S11, S21, S12, S22: lin Frequency Sweep
!Thursday, April 15, 2021  13 : 52
# Hz  S  dB  R 50.000
! Worked out from all points (through path):
!   801 points, 10 MHz to 67 GHz, reference 50 ohm
!   highest |S21| = -0.05 dB at 10 MHz (marker M1); lowest = -3.5 dB at 66.75 GHz (marker M2)
!   lowest |S11| = -67.1 dB at 36.85 GHz (marker M3), VSWR 1.00, Z = 50 + j0.0194 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -64.5 to -20.7 dB; largest |S21 - S12| = 0.0085
!   the Smith chart shows 30.99 GHz to 43.55 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -43.5  0.0  0.0  -55.4
! 1.434 GHz  -35.1  -0.5  -0.5  -38.7
! 3.443 GHz  -35.5  -0.7  -0.7  -36.0
! 11.23 GHz  -45.5  -1.3  -1.3  -32.1
! 12.07 GHz  -23.0  -1.4  -1.4  -25.0
! 12.74 GHz  -34.8  -1.4  -1.4  -38.9
! 14.08 GHz  -38.1  -1.5  -1.5  -41.9
! 16.17 GHz  -31.7  -1.6  -1.6  -30.0
! 22.37 GHz  -29.6  -1.8  -1.8  -35.1
! 24.71 GHz  -36.2  -1.9  -1.9  -37.6
! 26.47 GHz  -38.2  -2.0  -2.0  -32.4
! 27.64 GHz  -30.0  -2.0  -2.0  -35.0
! 31.58 GHz  -30.0  -2.2  -2.2  -36.3
! 33.51 GHz  -29.6  -2.3  -2.3  -27.8
! 36.85 GHz  -67.1  -2.4  -2.4  -46.5
! 44.73 GHz  -39.1  -2.9  -2.9  -46.8
! 51.34 GHz  -34.1  -3.2  -3.2  -38.8
! 55.86 GHz  -23.6  -3.4  -3.5  -22.5
! 58.71 GHz  -31.1  -3.4  -3.4  -28.3
! 62.73 GHz  -36.1  -3.4  -3.4  -32.9
! 66.75 GHz  -32.8  -3.5  -3.5  -27.9
! 67 GHz  -27.1  -3.5  -3.5  -25.3
