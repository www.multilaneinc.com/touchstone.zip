!Keysight Technologies,N5225A,MY51451228,A.10.40.14
!Date: Friday, November 20, 2020 11:27:36
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (through path):
!   201 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = 0.02 dB at 10 MHz (marker M1); lowest = -3.0 dB at 40 GHz (marker M2)
!   lowest |S11| = -55.0 dB at 33.4 GHz (marker M3), VSWR 1.00, Z = 50.1 - j0.113 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -50.5 to -19.9 dB; largest |S21 - S12| = 0.019
!   the Smith chart shows 18.61 GHz to 40 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -22.6  0.0  -0.1  -25.1
! 609.9 MHz  -51.2  -0.3  -0.3  -50.5
! 809.8 MHz  -32.7  -0.3  -0.3  -32.9
! 3.209 GHz  -26.2  -0.7  -0.7  -26.4
! 6.808 GHz  -38.0  -1.1  -1.1  -38.6
! 13.41 GHz  -26.1  -1.6  -1.6  -28.0
! 20 GHz  -32.0  -2.0  -2.0  -31.8
! 25.2 GHz  -34.4  -2.2  -2.2  -39.2
! 26.8 GHz  -24.1  -2.3  -2.3  -19.9
! 28 GHz  -30.6  -2.3  -2.3  -41.3
! 28.4 GHz  -29.7  -2.4  -2.4  -22.2
! 30.8 GHz  -27.4  -2.5  -2.5  -25.0
! 31 GHz  -31.4  -2.5  -2.5  -41.4
! 32.4 GHz  -23.4  -2.6  -2.6  -24.5
! 32.6 GHz  -42.7  -2.6  -2.5  -28.7
! 33.2 GHz  -33.9  -2.6  -2.6  -28.4
! 33.4 GHz  -55.0  -2.6  -2.6  -32.0
! 33.8 GHz  -30.4  -2.7  -2.7  -38.5
! 36.8 GHz  -22.1  -2.9  -2.8  -23.9
! 37.2 GHz  -41.9  -2.8  -2.8  -35.1
! 37.4 GHz  -22.8  -2.9  -2.8  -23.9
! 40 GHz  -24.6  -3.0  -2.9  -23.8
