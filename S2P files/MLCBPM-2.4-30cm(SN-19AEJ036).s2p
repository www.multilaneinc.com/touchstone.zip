!Keysight Technologies,N5225A,MY51451228,A.10.40.14
!Date: Friday, November 20, 2020 11:40:44
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (through path):
!   201 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = 0.04 dB at 10 MHz (marker M1); lowest = -1.5 dB at 40 GHz (marker M2)
!   lowest |S11| = -58.7 dB at 7.208 GHz (marker M3), VSWR 1.00, Z = 50.1 - j0.0854 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -55.8 to -15.8 dB; largest |S21 - S12| = 0.028
!   the Smith chart shows 10 MHz to 24.2 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -22.0  0.0  -0.2  -25.1
! 209.9 MHz  -43.8  -0.1  -0.1  -41.4
! 5.009 GHz  -31.5  -0.5  -0.5  -29.3
! 6.008 GHz  -55.6  -0.5  -0.5  -39.5
! 6.408 GHz  -38.8  -0.6  -0.6  -55.8
! 6.808 GHz  -39.9  -0.6  -0.6  -40.5
! 7.208 GHz  -58.7  -0.6  -0.6  -49.8
! 7.808 GHz  -31.6  -0.6  -0.6  -39.7
! 13.41 GHz  -34.2  -0.7  -0.7  -38.2
! 20 GHz  -28.2  -0.9  -0.9  -31.4
! 21.8 GHz  -37.6  -1.0  -1.0  -46.3
! 23 GHz  -24.4  -1.0  -1.0  -24.3
! 23.6 GHz  -29.1  -1.0  -1.0  -42.0
! 26.8 GHz  -26.7  -1.1  -1.1  -24.1
! 28.2 GHz  -22.5  -1.1  -1.1  -22.7
! 28.4 GHz  -45.6  -1.1  -1.1  -31.3
! 28.6 GHz  -21.6  -1.1  -1.1  -22.4
! 30.8 GHz  -17.9  -1.2  -1.2  -19.9
! 31 GHz  -27.0  -1.1  -1.1  -43.0
! 31.2 GHz  -19.3  -1.1  -1.1  -20.7
! 33.4 GHz  -27.0  -1.2  -1.2  -29.6
! 40 GHz  -15.5  -1.5  -1.5  -16.1
