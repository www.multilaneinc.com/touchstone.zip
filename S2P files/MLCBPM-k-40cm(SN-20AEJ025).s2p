!Keysight Technologies,N5225A,MY51451228,A.10.40.14
!Date: Friday, November 20, 2020 11:35:39
!Correction: S11(Full 2 Port(1,2))
!S21(Full 2 Port(1,2))
!S12(Full 2 Port(1,2))
!S22(Full 2 Port(1,2))
!S2P File: Measurements: S11, S21, S12, S22:
# Hz S  dB  R 50
! Worked out from all points (through path):
!   201 points, 10 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -0.02 dB at 10 MHz (marker M1); lowest = -1.4 dB at 39.2 GHz (marker M2)
!   lowest |S11| = -53.3 dB at 11.01 GHz (marker M3), VSWR 1.00, Z = 50.2 - j0.0936 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -50.9 to -18.8 dB; largest |S21 - S12| = 0.022
!   the Smith chart shows 3.209 GHz to 18.41 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 10 MHz  -22.4  0.0  -0.1  -25.7
! 6.808 GHz  -27.2  -0.5  -0.5  -26.2
! 8.008 GHz  -22.0  -0.5  -0.5  -21.6
! 8.208 GHz  -36.0  -0.5  -0.5  -44.1
! 8.408 GHz  -23.0  -0.5  -0.5  -22.8
! 10.81 GHz  -25.8  -0.6  -0.6  -24.8
! 11.01 GHz  -53.3  -0.6  -0.6  -41.1
! 11.21 GHz  -26.0  -0.6  -0.6  -26.5
! 13.41 GHz  -22.0  -0.7  -0.7  -21.9
! 14.01 GHz  -21.7  -0.7  -0.7  -21.7
! 14.21 GHz  -48.6  -0.7  -0.7  -50.9
! 14.41 GHz  -21.6  -0.7  -0.7  -21.4
! 15.61 GHz  -24.0  -0.7  -0.7  -24.6
! 15.81 GHz  -44.5  -0.7  -0.7  -46.7
! 16.01 GHz  -22.3  -0.7  -0.7  -23.9
! 20 GHz  -25.5  -0.9  -0.9  -26.7
! 26.8 GHz  -23.5  -1.1  -1.1  -21.9
! 33.4 GHz  -24.7  -1.1  -1.1  -27.0
! 33.6 GHz  -35.8  -1.2  -1.1  -46.2
! 34.4 GHz  -24.5  -1.2  -1.2  -24.1
! 39.2 GHz  -25.3  -1.4  -1.4  -21.3
! 40 GHz  -33.3  -1.3  -1.2  -28.8
